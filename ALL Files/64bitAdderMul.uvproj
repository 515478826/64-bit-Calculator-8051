# Keil uVision project 64bitAdderMul.uvproj, settings and files
target Target 1 (MCS-51)
  device: P87C51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: 64bitAdderMul +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 uart.c app.c calc.c dataparse.c
